Properties of the parts of a building model (IFC2X3)

# File
Description: Einbau-Kanaltemperaturfühler, PT 100, Einbaulänge 165 mm, ViewDefinition[CoordinationView]
File name: ifc-2x3.ifc
Time: 2026-04-23T13:34:05+0000
Author: ALRE-IT Regeltechnik GmbH, mail@alre.de
Organization: ALRE-IT Regeltechnik GmbH, Richard-Tauber-Damm 10, 12277 Berlin, +49 30 39984-0, https://alre.de
Written by: 2.0.0
Made in: ALRE-IT BMEcat2IFC Exporter
Authorization: N/A

# IfcBuildingStorey, Geschoss
In: Gebaeude
Elevation: 0 m

# IfcBuildingElementProxy: G9140270, Einbau-Kanaltemperaturfühler, PT 100, Einbaulänge 165 mm
In: Raum
Description: Die Einbaukanalfühler EKF werden zur Messung der Temperaturen in Flüssigkeiten und Gasen in Rohrleitungen, Luftkanälen oder Behältern eingesetzt. Zum Einsatz in Luftkanälen wird der Montageflansch (MF) benötigt. Bei Verwendung in Flüssigkeiten sind Tauchhülsen aus Messing vernickelt (THMs) einzusetzen. Für aggressive Medien werden Tauchhülsen aus Edelstahl V4A (THV) empfohlen. Tauchhülsen oder Montageflansch gehören nicht zum Lieferumfang und müssen als Zubehör separat bestellt werden.; Classification: EC004240 ETIM-Klasse (ETIM)
Pset_ManufacturerTypeInformation - Manufacturer: ALRE-IT Regeltechnik GmbH; ModelReference: G9140270; ModelLabel: EKFP 100/150; GlobalTradeItemNumber: 4050528039422; ProductURL: https://alre.de/produkt_G9140270
Pset_Specification - NominalLength: 0.199 m; NominalWidth: 0.064 m; NominalDepth: 0.058 m; NetWeight: 0.115
Pset_ALRE_ETIM_Properties - Gehäusefarbe: weiß; Mit Gehäuse: yes; Art der Spannungsversorgung: ohne; Geeignet für Rohrmontage: yes; Umgebungstemperatur: -30; Ausführung des elektrischen Anschlusses: Schraubanschluss; Deckelbefestigung: Bajonettverschluss; Explosionsgeschützt: no; Einsatzgebiet: Tauchrohr/-kanal; Temperaturmessbereich: -30; Sensorelement innerhalb des Gehäuses: no; Aktive Temperaturmessung: no; Passive Temperaturmessung: yes; Max. Umgebungsfeuchtigkeit (nicht kondensierend): 95; Sensorelement außerhalb des Gehäuses: yes; Sensortyp: Pt100; Einstecklänge: 165; Gehäusehöhe: 64; Gehäusebreite: 58; Gehäusetiefe: 199; Geeignet für Kanalbefestigung: yes; Festes Kabel am Sensor: no; Länge des Sensors: 150; ETIM-Klasse: EC004240; ETIM-Version: ETIM-10.0
Pset_ALRE_Dokumente - Datenblatt: https://media.alre.de/deu_DEU/datasheet/ALRE_Datenblatt-G9140270.pdf
